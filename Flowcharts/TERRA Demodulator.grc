options:
  parameters:
    author: Aang23
    generate_options: qt_gui
    id: terrademod
    output_language: python
    title: TERRA Demodulator
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 45.0e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/symb_rate
  states: {}
- name: symb_rate
  id: variable
  parameters:
    value: 13.125e6
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-1'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-127'
    type: float
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: float
  states: {}
- name: blocks_deinterleave_0_0
  id: blocks_deinterleave
  parameters:
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /run/media/alan/86a00fd2-c58e-4a0e-9c80-ad067b3b7997/X-Band/Terra_8212MHz_153M6.raw
    repeat: 'False'
    type: short
  states: {state: disabled}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '127'
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_interleaved_char_to_complex_0_0
  id: blocks_interleaved_char_to_complex
  parameters:
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_interleaved_short_to_complex_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.6'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.004'
    type: float
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.001'
    gain_omega: 0.001**2/4.0
    mu: '0.5'
    omega: sps/2
    omega_relative_limit: '0.005'
    type: complex
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.0063'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: Real branch
    size: '1024'
    type: complex
    update_time: '0.010'
  states: {}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    name: Main
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '1.0'
    decim: '1'
    gain: '1'
    ntaps: '361'
    samp_rate: samp_rate
    sym_rate: symb_rate*4
    type: fir_filter_ccf
  states: {}

connections:
- [analog_agc_xx_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_agc_xx_0_0, '0', root_raised_cosine_filter_0_0, '0']
- [analog_rail_ff_0, '0', blocks_float_to_char_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_complex_to_float_0_0, '0', blocks_float_to_complex_1_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_delay_0, '0']
- [blocks_complex_to_float_1_0, '0', blocks_deinterleave_0, '0']
- [blocks_complex_to_float_1_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_deinterleave_0, '0', blocks_float_to_complex_1, '0']
- [blocks_deinterleave_0, '1', blocks_float_to_complex_1, '1']
- [blocks_deinterleave_0_0, '0', blocks_float_to_complex_0_0, '1']
- [blocks_deinterleave_0_0, '1', blocks_float_to_complex_0_0, '0']
- [blocks_delay_0, '0', blocks_float_to_complex_1_0, '1']
- [blocks_file_source_0_0, '0', blocks_interleaved_char_to_complex_0_0, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_short_to_complex_0_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_float_to_char_0, '0', blocks_file_sink_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_float_to_complex_1, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_float_to_complex_1_0, '0', digital_clock_recovery_mm_xx_0_0, '0']
- [blocks_interleaved_char_to_complex_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_rail_ff_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_deinterleave_0_0, '0']
- [blocks_throttle_0_0, '0', analog_agc_xx_0_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', blocks_complex_to_float_1_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', qtgui_const_sink_x_0_1, '0']
- [digital_costas_loop_cc_0_0, '0', blocks_complex_to_float_0_0, '0']
- [root_raised_cosine_filter_0_0, '0', digital_costas_loop_cc_0_0, '0']

metadata:
  file_format: 1
